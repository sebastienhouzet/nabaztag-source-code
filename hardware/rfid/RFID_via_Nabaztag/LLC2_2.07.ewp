# IAR project LLC2_2.07.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: ML67Q4051 OKI ML67Q4051
  ICCARM.CCDefines: __IAR__
  ICCARM.CCIncludePath2: Include; COMMON\INC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: common\SRC\67405x_memory.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ML67Q4051 Oki ML67Q4051
  ICCARM.CCDefines: NDEBUG; __IAR__
  group (top)
    COMMON/SRC/: 67405x_cstartup_IAR.s79 67405x_memory.xcl IAR_reentrant_irq.s79 IAR_swi_handler.s79 irq.c
    ./: audio.c bc.c delay.c eapol.c hash.c hcd.c hcdmem.c i2c.c ieee80211.c led.c list.c main.c mem.c motor.c okijob.c otg.c rc4.c rfid.c rt2501usb.c rt2501usb_buffer.c rt2501usb_io.c spi.c uart.c usbctrl.c usbhcore.c vaudio.c vinterp.c vloader.c vlog.c vmem.c vnet.c
