# IAR project Backup of LLC2_2.07.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: ML67Q4051 OKI ML67Q4051
  ICCARM.CCDefines: __IAR__
  ICCARM.CCIncludePath2: Include; COMMON\INC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: COMMON\SRC\67405x_memory.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    COMMON/SRC/: 67405x_cstartup_IAR.s79 67405x_memory.xcl IAR_reentrant_irq.s79 IAR_swi_handler.s79 irq.c
    ./: audio.c delay.c hcd.c hcdmem.c led.c list.c main.c mem.c motor.c okijob.c otg.c spi.c uart.c usbctrl.c usbhcore.c
