<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LLC2_2.07.ewp</path>
  </project>
  <batchBuild/>
</workspace>


